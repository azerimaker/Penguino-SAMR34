# Repository azerimaker/Penguino-SAMR34

File README.md:

# Penguino Feather LoRa development board
This repo contains all the necessary design and fabrication files for the Penguino radio module and its @Adafruit Father style breakout board. First prototype batch is being sold on my [Tindie](https://www.tindie.com/products/16985/) store.

### Penguino Feather v1.1:

## Penguino RF Module v1.2 Specs:
- [ATSAMR34J18](http://ww1.microchip.com/downloads/en/DeviceDoc/SAMR34-R35-Low-Power-LoRa-Sub-GHz-SiP-Data-Sheet-DS70005356B.pdf) LoRA System-in-Package (SiP) based RF module
- ARM Cortex M0+ MCU & LoRa Radio
- 256KB Flash, 40 KB RAM
- Power Output: 20.00(dBm) (DS value, real output is not tested)
- Frequency Range: 862 to 1020 MHz (DS values)
- Sleep Current: ~810 nA 
- IO pins: 27
- Module Dimenions: ~16.5x14x2 mm

### Penguino RF Module v1.1:

### Penguino Feather v1.1 Blinky:

License:
- Hardware license: CERN-OHL-S v2
- Software license: under MIT unless otherise indicated 
- Documentation license:  CC BY-SA 4.0 International.

________________________________
## Open Source Hardware
This board is an OSHWA approved design: [AZ000002](https://certification.oshwa.org/az000002.html)

## KiCad design Penguino-Hardware/Penguino-Feather-4260-v1/Penguino-Feather-4260-v1.kicad_pcb

Parts:
C1, C2, C3: 10uF; C_0603_1608Metric
C4, C9: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104
C5: 47pF; C_0402_1005Metric
C6, C7: DNM; C_0402_1005Metric
C8, C12: 10nF; C_0603_1608Metric; MPN CC0603KRX7R9BB103
C10: 1uF; C_0603_1608Metric; MPN CC0603KRX7R8BB105
C11, C13: 100nF; C_0402_1005Metric; MPN CC0603KRX7R9BB104
D1: MBR0520; D_SOD-123; MPN MBR0520
D2: CH_ORANGE; LED_0603_1608Metric
D3: PGB1010402; L_0402_1005Metric; MPN PGB1010402KR
D4: PWR_BLUE; LED_0603_1608Metric
D5: FM-B2020RGBA; LED_Cree-PLCC4_2x2mm_CW; MPN FM-B2020RGBA-HG
F1: 1A; Fuse_0805_2012Metric; MPN 0805L110SLYR
FB1: BLM18HE152SN1D; L_0603_1608Metric; MPN BLM18HE152SN1D
J1: U.FL-R-SMT-1; U.FL_Hirose_U.FL-R-SMT-1_Vertical; MPN U.FL-R-SMT-1(80)
J2: SMA-Edge-Mount; SMA_J_P_X_ST_EM1_EdgeMount; MPN SMA-J-P-H-ST-EM1
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G; MPN TYPE-C-31-M-12
J4: JST_PH; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal; MPN S2B-PH-SM4-TB(LF)(SN)
J5: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical_SMD
JP1: PWRLED-Cut; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP2: RGB-Cut; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP3: ADCV-Cut; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP4: ADC-PIN-Cut; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
Q1: SI2323DS; SOT-23; MPN SI2323DS-T1-E3
R1: DNM; R_0402_1005Metric
R2: 0R; R_0402_1005Metric
R3, R5: 100K; R_0402_1005Metric
R4, R7, R9, R10, R11: 1K5; R_0402_1005Metric
R6, R13, R14: 4K7; R_0402_1005Metric
R8, R17: 10K; R_0402_1005Metric
R12, R15: 1M; R_0402_1005Metric
R16: 3M6; R_0402_1005Metric; MPN RC0402JR-073M6L
SW1: USR_BTN; SW_Push_SKRPACE010; MPN SKRPACE010
SW2: RESET; SW_Push_SKRPACE010; MPN SKRPACE010
U1: MCP73831; SOT-23-5; MPN MCP73831-2-OT
U2: ME6215C33; SOT-23-5; MPN ME6215C33
U3: MAX809STRG; SOT-23; MPN MAX809STRG
U4: RAK4260; RAK4260-footprint_w_solder_paste
U5: NUP2202; SOT-363_SC-70-6; MPN NUP2202W1T2G
U6: Feather-Generic
U7: ATECC608A-TNGLORAS; SOIC-8_3.9x4.9mm_P1.27mm; MPN ATECC608A-TNGLORAS-B
U8: W25Q16JVSS; SOIC-8_5.23x5.23mm_P1.27mm

Connections:
+3V3: C3.1, C4.1, C10.1, J5.1 (VTref), JP1.1 (A), JP2.1 (A), R8.1, R13.1, R14.1, R17.2, U2.5 (OUT), U4.11, U4.12, U6.2 (3V), U7.8 (VCC), U8.3 (IO2), U8.7 (IO3), U8.8 (VCC)
+BATT: C1.1, J4.1, JP3.1 (A), Q1.3 (D), U1.3 (VBAT), U6.28 (VBAT)
/Vin: C8.1, FB1.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), U5.5
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.1, D3.2 (A2), J1.2 (Ext), J2.2 (Ext), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J4.2, J5.3 (GND), J5.5 (GND), J5.9 (GNDDetect), R5.2, R6.2, R7.2, R12.1, R16.1, SW1.1, SW2.1, U1.2 (VSS), U2.2 (GND), U3.1 (GND), U4.1, U4.3, U4.10, U4.17, U4.18, U4.28, U4.35, U4.36, U4.37, U5.2, U6.4 (GND), U6.16 (GND), U7.4 (GND), U8.4 (GND)
LDO_EN: R3.1, U2.3 (EN), U6.27 (EN)
unnamed: C5.1, C7.1, U4.2
unnamed: C5.2, C6.1, D3.1 (A1), R1.1, R2.2
unnamed: C9.1, F1.1, FB1.2
unnamed: C12.2, J3.S1 (SHIELD), R12.2
unnamed: C13.2, JP4.2 (B), R15.1, R16.2
unnamed: D2.1 (K), U1.1 (STAT)
unnamed: D2.2 (A), R4.2
unnamed: D4.1 (K), R7.1
unnamed: D4.2 (A), JP1.2 (B)
unnamed: D5.1 (RK), R9.1
unnamed: D5.2 (BK), R11.1
unnamed: D5.3 (A), JP2.2 (B)
unnamed: D5.4 (GK), R10.1
unnamed: J1.1 (In), R1.2
unnamed: J2.1 (In), R2.1
unnamed: JP3.2 (B), R15.2
unnamed: R3.2, U3.2 (~RESET)
unnamed: R6.1, U1.5 (PROG)
PA04_TX1: U4.32, U6.15 (Tx)
PA05_RX1: U4.33, U6.14 (Rx)
PA06_AIN6: U4.5, U6.20
PA07_AIN7: U4.6, U6.21
PA08_AIN0: JP4.1 (A), U4.7, U6.22
PA09_AIN1: U4.8, U6.23
PA14: R11.2, U4.16, U6.5
PA15: SW1.2, U4.15, U6.25
PA16_I2C_SDA: R13.2, U4.14, U6.17 (SDA), U7.5 (SDA)
PA17_I2C_SCL: R14.2, U4.13, U6.18 (SCL), U7.6 (SCL)
PA18_TX3: R10.2, U4.20, U6.6
PA19_RX3: R9.2, U4.19, U6.7
PA22_SS: U4.23, U6.10
PA23_MOSI: U4.22, U6.12 (MOSI), U8.5 (DI(IO0))
PA27: U4.4, U6.19
PA30_SWDCLK: J5.4 (SWDCLK/TCK), U4.30, U6.8
PA31_SWDIO: J5.2 (SWDIO/TMS), U4.31, U6.9
PB02_MISO: U4.25, U6.13 (MISO), U8.2 (DO(IO1))
PB03_NC_BCKP: U4.34, U6.3
PB22_FlashCS: R17.1, U4.9, U6.24, U8.1 (~CS)
PB23_SCK: U4.24, U6.11 (SCK), U8.6 (CLK)
USB_N: J3.A7 (D-), J3.B7 (D-), U4.27, U5.1
USB_P: J3.A6 (D+), J3.B6 (D+), U4.26, U5.6
VBUS: D1.2 (A), F1.2, Q1.1 (G), R4.1, R5.1, U1.4 (VDD), U6.26 (VBUS)
VDD_IN: C2.1, D1.1 (K), Q1.2 (S), U2.1 (IN), U3.3 (VDD)
~RESET: C11.1, J5.10 (~RESET~), R8.2, SW2.2, U4.29, U6.1 (RST)

Notes on the sheet:
10K = 100mA 5K = 200mA 4K7 = 220mA 2K = 500mA 1K = 1000mA
3.7V LiPo/Li-ion Battery Input
Battery Charging
USB-C Input Protection & Filtering
Indicator LEDs
RAK4260 ATSAMR34 based RF+MCU Module
Feather Compatible Pinout
Battery Monitoring
R1 and R2 share a common pad
Cortex SWD Connector
90 Ω diff trace
50 Ω trace
SAMR34 Pins which are NC/used internally:
Pre-Provisioned secure element with LoRaWAN TTN Join Server SOIC-8 (Optional)
Buttons
+3.3V LDO Regulator & Protection
Battery Supervisor
LDO variants: ME6215C33 - 300 mA max. 6 μA S-1313C33 - 200 mA max. 0.9 μA
3V cutoff
or TPS3839DBZ
or S-1313C33
Supervisor variants: MAX809STRG- 0.6 μA TPS3839DBZ- 150 nA
2MB SPI FLASH (optional)
BAND_SEL RFSW VCC TCXO PWR
PA13 PA28 PB03
PA13 PA09 PA09
RAK4260 TLM01-v1.2

Board: 4 copper layers, 22.9 x 50.8 mm, 57 parts (0 on the bottom side), 49 nets.

File Penguino-Hardware/Penguino-Feather-4260-v1/fabrication/BOM-Penguino-Feather-4260-v1.xlsx:

Name: | Penguino-Feather-4260-v1.0
Date: | 11/9/2019 7:39:27 PM
Tool: | Eeschema (5.1.5)
Total Component Count: | 49
Unique Component Count: | 34
Item | Qty | Reference(s) | MPN | Alternative Part | Value | Footprint | URL | URL (alt)
1 | 3 | C1, C2, C3 | CL10A106MO8NQNC |  | 10uF | Capacitor_SMD:C_0603_1608Metric | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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 | ~
2 | 2 | C4, C9 | CC0603KRX7R9BB104 |  | 100nF | Capacitor_SMD:C_0603_1608Metric | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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 | ~
3 | 1 | C5 | GJM1555C1H470JB01D |  | 47pF | Capacitor_SMD:C_0402_1005Metric | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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 | ~
4 |  | C6, C7 | - |  | DNM | Capacitor_SMD:C_0402_1005Metric |  | ~
5 | 2 | C8, C12 | CC0603KRX7R9BB103 |  | 10nF | Capacitor_SMD:C_0603_1608Metric | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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 | ~
6 | 1 | C10 | CC0603KRX7R8BB105 |  | 1uF | Capacitor_SMD:C_0603_1608Metric | https://lcsc.com/product-detail/Others_YAGEO-CC0603KRX7R8BB1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 | ~
7 | 2 | C11, C13 | CC0402MRY5V8BB104 |  | 100nF | Capacitor_SMD:C_0402_1005Metric | https://lcsc.com/product-detail/Others_YAGEO-CC0402MRY5V8BB1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 | ~
8 | 1 | D1 | MBR0520 |  | MBR0520 | Diode_SMD:D_SOD-123 | https://lcsc.com/product-detail/Schottky-Barrier-Diodes-SBD_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 | ~
9 | 1 | D2 | 19-217/S2C-AL1M2VY/3T |  | CH_ORANGE | LED_SMD:LED_0603_1608Metric | https://lcsc.com/product-detail/Others_Everlight-Elec-19-217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 | ~
10 | 1 | D3 | PGB1010402KR |  | PGB1010402 | Inductor_SMD:L_0402_1005Metric | https://lcsc.com/product-detail/Diodes-ESD_Littelfuse-PGB101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 | ~
11 | 1 | D4 | FC-DA1608BK-470H10 |  | PWR_BLUE | LED_SMD:LED_0603_1608Metric | https://lcsc.com/product-detail/Light-Emitting-Diodes-LED_Bl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 | ~
12 | 1 | D5 | FM-B2020RGBA-HG |  | RGB LED 2020 | LED_SMD:LED_Cree-PLCC4_2x2mm_CW | https://lcsc.com/product-detail/Light-Emitting-Diodes-LED_Fo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 | ~
13 | 1 | F1 | 0805L110SLYR |  | 1A | Fuse:Fuse_0805_2012Metric | https://lcsc.com/product-detail/Surface-Mount-Fuses_Littelfu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 | ~
14 | 1 | FB1 | BLM18HE152SN1D |  | BLM18HE152SN1D | Inductor_SMD:L_0603_1608Metric | https://lcsc.com/product-detail/Ferrite-Beads-And-Chips_muRa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 | ~
15 | 1 | J1 | U.FL-R-SMT-1(80) |  | U.FL-R-SMT-1 | Connector_Coaxial:U.FL_Hirose_U.FL-R-SMT-1_Vertical | https://lcsc.com/product-detail/_Hirose_U-FL-R-SMT-1-80_Hiro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 | ~
16 | 1 | J2 | SMA-J-P-H-ST-EM1 |  | SMA-Edge-Mount | tinylora_v1:SMA_J_P_X_ST_EM1_EdgeMount | https://www.ebay.com/itm/293146230861 | ~
17 | 1 | J3 | TYPE-C-31-M-12 |  | USB_C_Receptacle_USB2.0 | Connector_USB:USB_C_Receptacle_Palconn_UTC16-G | https://lcsc.com/product-detail/USB-Connectors_Korean-Hropar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 | ~
18 | 1 | J4 | S2B-PH-SM4-TB(LF)(SN) |  | JST_PH | Connector_JST:JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal | https://www.aliexpress.com/item/32513477927.html?spm=a2g0o.c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 | ~
19 | 1 | J5 | - | FTSH-105-01-F-DV-K | Male PCB Header Dual row | Connector_PinHeader_1.27mm:PinHeader_2x05_P1.27mm_Vertical_SMD | https://www.aliexpress.com/item/-/33030461496.html?spm=a2g0o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 | https://www.digikey.com/product-detail/en/samtec-inc/FTSH-10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
20 | 1 | Q1 | SI2323DS-T1-E3 |  | SI2323DS | Package_TO_SOT_SMD:SOT-23 | https://lcsc.com/product-detail/MOSFET_Vishay-Intertech-SI23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 | ~
21 |  | R1 | - | 0R | DNM | Resistor_SMD:R_0402_1005Metric | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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 | ~
22 | 1 | R2 | RC0402JR-070RL |  | 0R | Resistor_SMD:R_0402_1005Metric | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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 | ~
23 | 2 | R3, R5 | RC0402JR-07100KL |  | 100K | Resistor_SMD:R_0402_1005Metric | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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 | ~
24 | 5 | R4, R7, R9, R10, R11 | RC0402FR-071K5L |  | 1K5 | Resistor_SMD:R_0402_1005Metric | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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 | ~
25 | 3 | R6, R13, R14 | RC0402FR-074K7L |  | 4K7 | Resistor_SMD:R_0402_1005Metric | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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 | ~
26 | 2 | R8, R17 | RC0402FR-0710KL |  | 10K | Resistor_SMD:R_0402_1005Metric | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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 | ~
27 | 2 | R12, R15 | 0402WGF1004TCE |  | 1M | Resistor_SMD:R_0402_1005Metric | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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 | ~
28 | 1 | R16 | RC0402JR-073M6L |  | 3M6 | Resistor_SMD:R_0402_1005Metric | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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 | ~
29 | 2 | SW1, SW2 | SKRPACE010 |  | USR_BTN, RESET | switch-footprints:SW_Push_SKRPACE010 | https://lcsc.com/product-detail/Tactile-Switches_ALPS_SKRPAC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 | ~
30 | 1 | U1 | MCP73831-2ACI-OT |  | LiPo battery charger IC | Package_TO_SOT_SMD:SOT-23-5 | https://lcsc.com/product-detail/PMIC-Battery-Management_Micr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 | ~
31 | 1 | U2 | ME6215C33 | S-1313C33 | +3.3V LDO Regulator | Package_TO_SOT_SMD:SOT-23-5 | https://lcsc.com/product-detail/Low-Dropout-Regulators-LDO_M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 | https://www.mouser.de/ProductDetail/ABLIC/S-1313C33-M5T1U3?q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
32 | 1 | U3 | MAX809STRG | TPS3839K33DBZR | 3V Voltage Supervisor | Package_TO_SOT_SMD:SOT-23 | https://lcsc.com/product-detail/Microprocessor-Microcontroll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 | https://lcsc.com/product-detail/PMIC-Supervisors_TI_TPS3839K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
33 | 1 | U4 | RAK4260 |  | RAK4260 | rak4260:RAK4260-footprint_w_solder_paste | https://store.rakwireless.com/products/rak4260-lora-module | ~
34 | 1 | U5 | NUP2202W1T2G |  | NUP2202 | Package_TO_SOT_SMD:SOT-363_SC-70-6 | https://lcsc.com/product-detail/TVS_ON-Semicon_NUP2202W1T2G_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 | ~
35 | 1 | U7 | ATECC608A-TNGLORAS-B |  | TTN Secure Element | Package_SO:SOIC-8_3.9x4.9mm_P1.27mm | https://www.microchipdirect.com/product/ATECC608A-TNGLORA | ~
36 | 1 | U8 | W25Q16JVSS |  | 2MB Flash Memory | Package_SO:SOIC-8_5.23x5.23mm_P1.27mm | https://lcsc.com/product-detail/FLASH_Winbond-Elec-W25Q16JVS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 | ~

## KiCad design Penguino-Hardware/TLM-v1.1/TLM-v1.kicad_pcb

Board: 4 copper layers, 14.0 x 16.5 mm, 54 parts (0 on the bottom side), 52 nets.

Parts:
C1: 10uF; C_0402_1005Metric
C2, C3, C4, C5, C6, C8, C9, C10, C11, C13, C14, C15, C35: 100nF; C_0201_0603Metric
C7: 33pF; C_0201_0603Metric
C12, C33: 4.7pF; C_0201_0603Metric
C16, C24, C26, C27: DNM; C_0201_0603Metric
C17: 18pF; C_0201_0603Metric
C18, C29: 3.9pF; C_0201_0603Metric
C19, C21, C32: 3.3pF; C_0201_0603Metric
C20, C31: 5.6pF; C_0201_0603Metric
C22: 47pF; C_0201_0603Metric
C23: 2.7pF; C_0201_0603Metric
C25: 4.7nF; C_0201_0603Metric
C28: 22pF; C_0201_0603Metric
C30: 8.2pF; C_0201_0603Metric
C34: 1nF; C_0201_0603Metric
C36, C37: 10pF; C_0201_0603Metric
FB1: BLM15AG121SN1D; L_0402_1005Metric
JP1: RFSW_VCC_SLCT; JP_NO_NC
L3: 2.2nH; L_0402_1005Metric
L4, L5, L7, L10, L11: 10nH; L_0201_0603Metric
L6, L8: 33nH; L_0201_0603Metric
L9: 11nH; L_0201_0603Metric
R1: 100K; R_0402_1005Metric
U1: TLM01; TLM-01-module
U2: ATSAMR34J18B; TFBGA-64_6.0x6.0mm_Layout8x8_P0.65mm
U3: SKY13373-460LF; QFN-12-1EP_3x3mm_P0.5mm_EP1.65x1.65mm
XC1: TYETBCSANF-32.000000; Oscilator_2.5x2.0
Y1: ABS05-32.768KHZ-9-T; ABS05_32.768KHz Crystal

Connections:
+BATT: C33.1, U1.23, U2.C3
ANT_PAD: U1.30, U3.11
BAND_SEL: U2.F6, U3.4
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.2, C18.2, C19.2, C20.2, C21.2, C23.2, C24.2, C25.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, U1.1, U1.18, U1.28, U1.29, U1.31, U2.A2, U2.B2, U2.B3, U2.B5, U2.B7, U2.D4, U2.D6, U2.E1, U2.E2, U2.F2, U2.G2, U2.G3, U2.G5, U2.G6, U2.G7, U2.H5, U3.2, U3.7, U3.8, U3.10, U3.12, U3.13, XC1.2
unnamed: C7.1, C8.1, U2.H2
unnamed: C9.1, U2.H4
unnamed: C14.1, U2.A5
unnamed: C16.1, C21.1, L5.2, U3.1
unnamed: C16.2, C20.1, L4.2, L5.1
unnamed: C17.1, C19.1, L4.1
unnamed: C17.2, C18.1, L3.2, L6.1
unnamed: C22.1, C23.1, L7.1
unnamed: C22.2, U3.9
unnamed: C26.1, C27.2, C31.1, L10.2, L11.1
unnamed: C26.2, C30.1, L9.2, L10.1
unnamed: C27.1, C32.1, L11.2, U3.3
unnamed: C28.1, L9.1
unnamed: C34.1, JP1.2, U3.6
PA04_S0_UART_TX: U1.27, U2.D3
PA05_S0_UART_RX: U1.26, U2.C4
PA06_ADC6: JP1.3, U1.2, U2.E3
PA07_ADC7: U1.4, U2.F3
PA08_GPIO: U1.6, U2.F4
PA14_GPIO: U1.12, U2.F8
PA15_GPIO: U1.11, U2.G8
PA16_S1_I2C_SDA: U1.9, U2.F7
PA17_S1_I2C_SCL: U1.8, U2.E6
PA18_PWM_T0_W2: U1.10, U2.E7
PA19_PWM_T0_W3: U1.13, U2.E8
PA22_GPIO: U1.14, U2.D8
PA23_S5_SPI_SS: U1.15, U2.D7
PA27_GPIO: U1.3, U2.E4
PA28_GPIO: U1.24, U2.C6
PA30_SWDCLK: U1.21, U2.C5
PA31_SWDIO: U1.22, U2.D5
PA_BOOST: L3.1, U2.F1
PB02_S5_SPI_MISO: U1.25, U2.B4
PB22_S5_SPI_MOSI: U1.5, U2.E5
PB23_S5_SPI_SCK: U1.7, U2.C7
RFI_HF: L7.2, U2.A1
RFO_HF: C28.2, C29.1, L8.2, U2.B1
TCXO_PWR: C35.1, U2.F5, XC1.4
TXRX_RF: U2.D2, U3.5
USB_N: U1.17, U2.B8
USB_P: U1.16, U2.C8
VDD: C3.1, C4.2, C5.1, C13.2, FB1.2, R1.1, U1.19, U2.A7, U2.A8, U2.G4, U2.H8
VDDA: C1.1, C2.1, C6.1, C10.1, C11.1, C12.1, FB1.1, JP1.1, U2.C1, U2.C2, U2.H3
VR_PA: C24.1, C25.1, L6.2, L8.1, U2.D1
XIN32: C36.1, U2.A3, Y1.1
XOUT32: C37.1, U2.A4, Y1.2
XTA: U2.H6, XC1.3
~RESET: C15.1, R1.2, U1.20, U2.B6

## KiCad design Penguino-Hardware/TLM-breakout-v1.2/TLM-breakout-v1_2.kicad_pcb

Parts:
C1: DNM; C_0402_1005Metric
C3, C5: 10uF; C_0603_1608Metric
C4: 1uF; C_0603_1608Metric; MPN CC0603KRX7R8BB105
C6, C8: 10nF; C_0603_1608Metric; MPN CC0603KRX7R9BB103
C7, C9: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104
D1: MBR0520; D_SOD-123; MPN MBR0520
D2: CH_ORANGE; LED_0603_1608Metric
D4: LED_PWR_BLUE; LED_0603_1608Metric
D5: LED0_RED; LED_0603_1608Metric
F1: 1A; Fuse_0805_2012Metric; MPN 0805L110SLYR
FB1: BLM18HE152SN1D; L_0603_1608Metric; MPN BLM18HE152SN1D
J1: SMA-Edge-Mount; SMA_J_P_X_ST_EM1_EdgeMount; MPN SMA-J-P-H-ST-EM1
J2: U.FL-R-SMT-1; U.FL_Hirose_U.FL-R-SMT-1_Vertical; MPN U.FL-R-SMT-1(80)
J3: JST_PH; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal; MPN S2B-PH-SM4-TB(LF)(SN)
J4: USB_B_Micro; USB_Micro-B_C10418; MPN Pads_Jumpers:USB_Micro-B_C10418
J5: Cortex_JTAG_SWD_10pin; PinHeader_2x05_P1.27mm_Vertical_SMD; MPN FTSH-105-01-F-DV-K
JP2: PWR_LED-Cut; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP3: LED0-Cut; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP4: ADCV-Cut; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP5: ADC-Cut; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
L1: 0R; L_0402_1005Metric
R1: DNM; R_0402_1005Metric
R2: 0R; R_0402_1005Metric
R4: 4K7; R_0402_1005Metric
R5: 100K; R_0402_1005Metric
R6, R8, R9: 1K5; R_0402_1005Metric
R7: 100R; R_0402_1005Metric
R10, R11: 1M; R_0402_1005Metric
R12: 3M6; R_0402_1005Metric; MPN RC0402JR-073M6L
SW3: RESET; SW_Push_SKRPACE010; MPN SKRPACE010
U1: TLM01; TLM-01-footprint_w_paste
U2: TP4054; SOT-23-5; MPN TP4054
U3: MAX809STRG; SOT-23; MPN MAX809STRG
U4: ME6215C33; SOT-23-5; MPN ME6215C33
U5: NUP2202; SOT-363_SC-70-6; MPN NUP2202W1T2G
U6: Feather-Generic

Connections:
+3V3: C4.1, C5.1, J5.1 (VCC), JP2.1 (A), U1.19 (VDD), U4.5 (OUT), U6.2 (3V)
+BATT: D1.2 (A), J3.1, JP4.1 (A), U2.3 (VBAT), U6.28 (VBAT)
BACKUP_BATT: U1.23 (VBAT), U6.3
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, J1.2 (Ext), J2.2 (Ext), J3.2, J4.5 (GND), J5.3 (GND), J5.5 (GND), J5.9 (GNDDetect), R4.2, R8.2, R9.2, R10.1, R12.1, SW3.1, U1.1 (GND), U1.18 (GND), U1.28 (GND), U1.29 (GND), U1.31 (GND), U2.2 (VSS), U3.1 (GND), U4.2 (GND), U5.2, U6.4 (GND), U6.16 (GND)
LDO_EN: R5.1, U4.3 (EN), U6.27 (EN)
unnamed: C1.1, L1.2, R1.2
unnamed: C6.1, FB1.1, J4.1 (VBUS), U5.5
unnamed: C7.1, F1.1, FB1.2
unnamed: C8.2, J4.6 (Shield), R10.2
unnamed: C9.2, JP5.2 (B), R11.1, R12.2
unnamed: D2.1 (K), U2.1 (STAT)
unnamed: D2.2 (A), R6.2
unnamed: D4.1 (K), R8.1
unnamed: D4.2 (A), JP2.2 (B)
unnamed: D5.1 (K), R9.1
unnamed: D5.2 (A), JP3.2 (B)
unnamed: J1.1 (In), R2.1
unnamed: J2.1 (In), L1.1
unnamed: JP4.2 (B), R11.2
unnamed: R1.1, R2.2, U1.30 (ANT)
unnamed: R4.1, U2.5 (PROG)
unnamed: R5.2, U3.2 (~RESET)
unnamed: R7.2, SW3.2
PA04_S0_UART_TX: U1.27, U6.15 (Tx)
PA05_S0_UART_RX: U1.26, U6.14 (Rx)
PA06_ADC6: U1.2, U6.19
PA07_ADC7: JP5.1 (A), U1.4, U6.21
PA08_GPIO: U1.6, U6.22
PA14_GPIO: U1.12, U6.25
PA15_GPIO: U1.11, U6.24
PA16_S1_I2C_SDA: U1.9, U6.17 (SDA)
PA17_S1_I2C_SCL: U1.8, U6.18 (SCL)
PA18_PWM_T0_W2: U1.10, U6.23
PA19_PWM_T0_W3: JP3.1 (A), U1.13, U6.5
PA22_GPIO: U1.14, U6.6
PA23_S5_SPI_SS: U1.15, U6.10
PA27_GPIO: U1.3, U6.20
PA28_GPIO: U1.24, U6.9
PA30_SWDCLK: J5.4 (SWDCLK/TCK), U1.21, U6.7
PA31_SWDIO: J5.2 (SWDIO/TMS), U1.22, U6.8
PB02_S5_SPI_MISO: U1.25, U6.13 (MISO)
PB22_S5_SPI_MOSI: U1.5, U6.12 (MOSI)
PB23_S5_SPI_SCK: U1.7, U6.11 (SCK)
USB_N: J4.2 (D-), U1.17 (USB_N), U5.1
USB_P: J4.3 (D+), U1.16 (USB_P), U5.6
VBUS: C3.1, D1.1 (K), F1.2, R6.1, U2.4 (VDD), U3.3 (VDD), U4.1 (IN), U6.26 (VBUS)
~RESET: J5.10 (~RESET~), R7.1, U1.20 (~RST), U6.1 (RST)

Notes on the sheet:
10K = 100mA 5K = 200mA 2K = 500mA 1K = 1000mA
Battery Input
Battery Charging
LDO Regulator and Voltage Supervisor
USB Input Protection & Filtering
Indicator LEDs
Buttons
TinyLora RF+MCU Module ATSAMR34
Feather Compatible Pinout
Battery Monitoring
GraphX
R1 and R2 have a common pad
Cortex SWD Connector
or MCP73831

Board: 2 copper layers, 22.9 x 50.8 mm, 42 parts (0 on the bottom side), 47 nets.

## Commit log

2019-02-27 TLM files added
    Initial commit.
2019-02-27 renders added
2019-02-27 readme updated
2019-02-28 readme
2019-02-28 TinyLora Breakout
    TinyLora Breakout files added
2019-03-06 TLM01-v.1.1 added
    Minor bug fixes and layout improvements
2019-03-14 BOMs added
    BOMs for TinyLoRa and its breakout added
2019-06-18 pics edited
2019-06-22 tlm-v1.1 files corrected
    added schematic
2019-06-22 links corrected
2019-06-22 readme fix
2019-06-22 readme typo fix
2019-06-22 fixed photos
2019-09-21 ver 1.2 files added
2019-10-17 Lib files updated
    Organized the lib files
2019-11-06 minor updates
2019-11-06 RAK4260 lib added
2019-11-06 TLM lib and RAK4260 modified
2019-11-06 Folder structure rearranged
2019-11-06 copy files deleted
2019-11-06 rak4260 3D
2019-11-06 RAK4260 PCB fix
2019-11-08 Redundant lib deleted
2019-11-08 Fixed PDF
2019-11-09 Minor changes
2019-11-09 TinyLoRa 4260 Files added
    Inital version of the RAK4260 Feather breakout added
2019-11-10 Latest version of TinyLoRa 4260
    Slight layout updates and added BOM
2019-11-11 TinyLoRa 4260 slight layout changes
2019-11-11 Readme update
2019-11-14 Naming updates
2019-11-20 Naming updates
    Project name is now Penguino
2019-12-11 Name changes
2019-12-16 Penguino 4260 v1.1 added
    SWD line fix and some layout changes (including Logo)
2019-12-16 RAK4260 datasheet pin error
    PA19 and PA18 are swapped
2019-12-16 Penguino FW example
    RGB blink
2020-01-19 Update Penguino_4260_v1.0_FW.zip
    Penguino 4260 LoRaWAN Example added
2020-01-23 Penguino examples added
    Exampel code for LoRaWAN and RGB LED toggle
2020-04-12 Repo celanup
    Penguino 4260 files are moved to a dedicated repo
2020-04-24 HW License added
2020-08-19 Fix: Readme, added OSHW logo
2020-08-21 Fix: Readme
